# Keil uVision project M0.uvprojx, settings and files
target RAM (ARM-ADS)
  device: LPC1114FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: M0 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ./: startup_LPC11xx.s
  group CMSIS
    ../common/src/: core_cm0.c system_LPC11xx.c
  group uCOSII
    ../uCOSII/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C
    ../uCOSII/cpu/: Os_cpu_c.c
  group Source
    ../Source/: main.c IRQ.C nxplpc11xx.c
  group Hardware
    ../Hardware/Uart0/: uart.c
    ../Hardware/EEPROM/: E2PROM.c
    ../Hardware/Cmd_process/: cmd_processbpk.c
target FLASH (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1113FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x6000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: M0 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\uCOSII;..\Hardware\Uart0;..\Hardware\Cmd_process;..\Hardware\EEPROM;..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT9: RAM 0x10000000 size 0x2000
software components: CMSIS:CORE 4.3.0
